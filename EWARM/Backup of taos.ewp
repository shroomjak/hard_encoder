# IAR project Backup of taos.ewp, settings and files
configuration taos (ARM, debug)
  General.OGChipSelectEditMenu: STM32F722RE ST STM32F722RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32F722xx; USE_HAL_DRIVER; ARM_MATH_CM7; __FPU_PRESENT
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/DSP/Include; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/FLASH
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: taos.bin
  ILINK.IlinkOutputFile: taos.out
  ILINK.IlinkIcfFile: stm32f722xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f722xx.s
  group Application/User
    ../Src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
    ../Inc/: main.h stm32f7xx_hal_conf.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_sin_f32.c
    ../Src/: system_stm32f7xx.c
  group Drivers/FLASH
    ../Drivers/FLASH/: cmd_defs.h spi_driver.c spi_driver.h standardflash.c standardflash.h
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_adc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_exti.c stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_utils.c
